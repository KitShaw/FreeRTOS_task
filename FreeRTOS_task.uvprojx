# Keil uVision project FreeRTOS_task.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_interrupt +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\CMSIS\CM3\CoreSupport;.\User;.\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;.\Lib\STM32F10x_StdPeriph_Driver\inc;.\Hal\led;.\Hal;.\Hal\lcd;.\Hal\usart;.\Hal\key;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\User\delay
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c
    ./User/delay/: delay.c
  group Hal
    ./Hal/usart/: usart.c
    ./Hal/led/: led.c
    ./Hal/key/: key.c
  group Lib
    ./Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_tim.c
  group CMSIS
    ./Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StartUp
    ./Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
